# IAR project WOWL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nrf52832_xxaa NordicSemi nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DEBUG; NRF52=1; NRF52832; BLE_STACK_SUPPORT_REQD; S132; NRF52; SOFTDEVICE_PRESENT; SWI_DISABLE0; NRF_SD_BLE_API_VERSION=3; __LINT__=0; CONFIG_NFCT_PINS_AS_GPIOS
  ICCARM.CCIncludePath2: ..\include; ..\..\Common\include; ..\..\..\..\Shared\include; W:\CPP_Util\DSPLib\include; W:\CPP_Util\DSPLib\env\nRF5_SDK\components; W:\CPP_Util\DSPLib\env\nRF5_SDK\components\ble\ble_advertising; W:\CPP_Util\DSPLib\env\nRF5_SDK\components\ble\common; W:\CPP_Util\DSPLib\env\nRF5_SDK\components\ble\ble_services; W:\CPP_Util\DSPLib\env\nRF5_SDK\components\ble\peer_manager; W:\CPP_Util\DSPLib\env\nRF5_SDK\components\device; W:\CPP_Util\DSPLib\env\nRF5_SDK\components\drivers_nrf; W:\CPP_Util\DSPLib\env\nRF5_SDK\components\drivers_nrf\clock; W:\CPP_Util\DSPLib\env\nRF5_SDK\components\drivers_nrf\common; W:\CPP_Util\DSPLib\env\nRF5_SDK\components\drivers_nrf\config; W:\CPP_Util\DSPLib\env\nRF5_SDK\components\drivers_nrf\delay; W:\CPP_Util\DSPLib\env\nRF5_SDK\components\drivers_nrf\hal; W:\CPP_Util\DSPLib\env\nRF5_SDK\components\libraries; W:\CPP_Util\DSPLib\env\nRF5_SDK\components\libraries\fds; W:\CPP_Util\DSPLib\env\nRF5_SDK\components\libraries\fstorage; W:\CPP_Util\DSPLib\env\nRF5_SDK\components\libraries\experimental_section_vars; W:\CPP_Util\DSPLib\env\nRF5_SDK\components\libraries\log; W:\CPP_Util\DSPLib\env\nRF5_SDK\components\libraries\log\src; W:\CPP_Util\DSPLib\env\nRF5_SDK\components\libraries\timer; W:\CPP_Util\DSPLib\env\nRF5_SDK\components\libraries\util; W:\CPP_Util\DSPLib\env\nRF5_SDK\components\softdevice\common\softdevice_handler; W:\CPP_Util\DSPLib\env\nRF5_SDK\components\softdevice\s132\headers; W:\CPP_Util\DSPLib\env\nRF5_SDK\components\toolchain; W:\CPP_Util
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: WOWL.srec
  ILINK.IlinkOutputFile: WOWL.out
  ILINK.IlinkIcfFile: WOWL.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; NRF52=1; NRF52832; BLE_STACK_SUPPORT_REQD; S132; NRF52; SOFTDEVICE_PRESENT; SWI_DISABLE0; NRF_SD_BLE_API_VERSION=3; __LINT__=0; CONFIG_NFCT_PINS_AS_GPIOS
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: WOWL.bin
  prebuild: cmd /C "del ..\obj\Release\wowlBle.*"
  postbuild: ielftool --ihex $TARGET_PATH$ $TARGET_DIR$\WOWL.hex
  group (top)
    ./: WOWL.icf
  group nRF5_SDK
    W:/CPP_Util/DSPLib/env/nRF5_SDK/components/libraries/timer/: app_timer.c
    W:/CPP_Util/DSPLib/env/nRF5_SDK/components/libraries/util/: app_util_platform.c sdk_mapped_flags.c
    W:/CPP_Util/DSPLib/env/nRF5_SDK/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    W:/CPP_Util/DSPLib/env/nRF5_SDK/components/ble/ble_advertising/: ble_advertising.c
    W:/CPP_Util/DSPLib/env/nRF5_SDK/components/ble/ble_services/ble_dis/: ble_dis.c
    W:/CPP_Util/DSPLib/env/nRF5_SDK/components/ble/ble_services/ble_lbs/: ble_lbs.c
    W:/CPP_Util/DSPLib/env/nRF5_SDK/components/libraries/fds/: fds.c
    W:/CPP_Util/DSPLib/env/nRF5_SDK/components/libraries/fstorage/: fstorage.c
    W:/CPP_Util/DSPLib/env/nRF5_SDK/components/ble/peer_manager/: gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c
    W:/CPP_Util/DSPLib/env/nRF5_SDK/components/toolchain/iar/: iar_startup_nrf52.s
    W:/CPP_Util/DSPLib/env/nRF5_SDK/components/drivers_nrf/delay/: nrf_delay.s
    W:/CPP_Util/DSPLib/env/nRF5_SDK/components/drivers_nrf/clock/: nrf_drv_clock.c
    W:/CPP_Util/DSPLib/env/nRF5_SDK/components/drivers_nrf/common/: nrf_drv_common.c
    W:/CPP_Util/DSPLib/env/nRF5_SDK/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    W:/CPP_Util/DSPLib/env/nRF5_SDK/components/drivers_nrf/saadc/: nrf_drv_saadc.c
    W:/CPP_Util/DSPLib/env/nRF5_SDK/components/drivers_nrf/spi_master/: nrf_drv_spi.c
    W:/CPP_Util/DSPLib/env/nRF5_SDK/components/drivers_nrf/twi_master/: nrf_drv_twi.c
    W:/CPP_Util/DSPLib/env/nRF5_SDK/components/libraries/log/src/: nrf_log_frontend.c
    W:/CPP_Util/DSPLib/env/nRF5_SDK/components/drivers_nrf/hal/: nrf_saadc.c
    W:/CPP_Util/DSPLib/env/nRF5_SDK/components/softdevice/common/softdevice_handler/: softdevice_handler.c
    W:/CPP_Util/DSPLib/env/nRF5_SDK/components/toolchain/: system_nrf52.c
  group Source
    ../src/: wowlAdc.c wowlAssert.c wowlBatt.c wowlBle.c wowlCmd.c wowlDfu.c wowlFlash.c wowlInit.c wowlLed.c wowlMain.c wowlPm.c wowlPress.c wowlSample.c wowlService.c wowlSm.c wowlTemp.c wowlTests.c
  group whfCppUtil
    W:/CPP_Util/src/: crc16.c CRC32.c lookupf.c
    W:/CPP_Util/DSPLib/src/arm/: delay_cycles.s spi_flash_nrf.c timer_nrf.c
    W:/CPP_Util/DSPLib/src/: timer_general.c
